# Keil uVision project BTC.uvprojx, settings and files
target BTC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BTC.out
  AfterMake: fromelf --bin -o ./@L.bin ./Objects/@L.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .\rtos\freertos_9.0.0\Source\portable\RVDS\ARM_CM4F;.\rtos\freertos_9.0.0\Source\include;.\CMSIS\Include;.\devices;.\devices\MK64F12\drivers;.\devices\MK64F12\utilities;.\middleware\lwip_2.0.0;.\middleware\lwip_2.0.0\port;.\middleware\lwip_2.0.0\port\arch;.\middleware\lwip_2.0.0\src;.\middleware\lwip_2.0.0\src\include;.\middleware\lwip_2.0.0\src\include\lwip;.\middleware\lwip_2.0.0\src\include\lwip\priv;.\middleware\lwip_2.0.0\src\include\netif;.\middleware\lwip_2.0.0\src\include\posix;.\middleware\lwip_2.0.0\contrib\apps;.\rtos\freertos_9.0.0\Source;.\devices\MK64F12;.\startup;.\rtos\freertos_9.0.0\Source\portable\RVDS\ARM_CM4F;.\middleware\lwip_2.0.0\contrib\apps\ping;.\middleware\lwip_2.0.0\src\include;.\cJSON;.\middleware\lwip\src\include\lwip;.\middleware\lwip\src\include\lwip\prot;.\driver_api;.\globalParams;.\tools;.\threadSource;.\ota;.\md5;.\source;.\crc16;.\sensor;.\board;.\board\src;..\BTC_APP
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: .\MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group source
    ./source/: flashLayout.h userConfig.h FreeRTOSConfig.h main.c
  group board
    ./board/: fsl_phy.c fsl_phy.h pin_mux.c pin_mux.h
  group board-src
    ./board/src/: board.c board.h clock_config.c clock_config.h
  group drivers
    ./devices/MK64F12/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_enet.c fsl_enet.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_i2c.c fsl_i2c.h fsl_ftm.c fsl_lptmr.c fsl_lptmr.h fsl_adc16.c fsl_adc16.h fsl_flash.c fsl_flash.h
  group utilities
    ./devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group startup
    ./devices/MK64F12/arm/: startup_MK64F12.s
    ./devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group lwip-port
    ./middleware/lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group lwip-port-arch
    ./middleware/lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ./middleware/lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ./middleware/lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ./middleware/lwip_2.0.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ./middleware/lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ./middleware/lwip_2.0.0/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ./middleware/lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-netif
    ./middleware/lwip_2.0.0/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
    ./middleware/lwip_2.0.0/src/include/netif/ppp/: pppoe.h
  group lwip-src-include-netif-ppp
    ./middleware/lwip_2.0.0/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ./middleware/lwip_2.0.0/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ./middleware/lwip_2.0.0/src/include/posix/: netdb.h
    ./middleware/lwip_2.0.0/src/include/posix/sys/: socket.h
  group lwip-src-include-posix-sys
    ./middleware/lwip_2.0.0/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ./middleware/lwip_2.0.0/src/netif/: ethernet.c ethernetif.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ./middleware/lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group freertos
    ./rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ./rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./rtos/freertos_9.0.0/Source/portable/MemMang/: heap_3.c
  group freertos-source-portable-RVDS-ARM_CM4F
    ./rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F/: fsl_tickless_systick.c port.c portmacro.h fsl_tickless_generic.h
  group cJSON
    ./cJSON/: cJSON.cpp cJSON.h
  group sensor
    ./sensor/: sensor.c sensor.h
  group md5
    ./md5/: md5Std.h mdk_test.cpp md5.c
  group driver_api
    ./driver_api/: i2c_api.c K64_api.h gpio_api.c ftm_api.c dhcp_api.c adc_api.c flash_api.c
  group globalParams
    ./globalParams/: globalParams.h apiParams.h
  group threadSource
    ./threadSource/: NetWork_Thread.c HeartBeat_Thread.c oneSecondTimer_Thread.c workHandle_Thread.c exceptionHandle_Thread.c thread_api.h
  group tools
    ./tools/: delay.c tools.h calculateBinSize.c getMAC.c
  group ota
    ./ota/: ota_api.c ota.h
  group crc16
    ./crc16/: lib_crc16.h crc16.c
