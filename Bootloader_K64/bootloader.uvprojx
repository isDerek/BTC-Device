# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .\board;.\board-src;.\source;.\startup;.\devices\MK64F12\drivers;.\devices\MK64F12\utilities\io;.\devices\MK64F12\utilities\str;.\devices\MK64F12\utilities\log;.\devices\MK64F12\utilities;.\devices\MK64F12;.\CMSIS\Include;.\drivers_api;.\md5;.\crc16
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\bootloader.scf
  link misc: --remove
  group Source
    ./source/: main.c flashLayout.h
  group board
    ./board/: pin_mux.c pin_mux.h
  group board-src
    ./board-src/: board.c board.h clock_config.c clock_config.h
  group utilities
    ./devices/MK64F12/utilities/io/: fsl_io.c fsl_io.h
    ./devices/MK64F12/utilities/log/: fsl_log.c fsl_log.h
    ./devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ./devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ./startup/: startup_MK64F12.s system_MK64F12.c system_MK64F12.h
  group drivers
    ./devices/MK64F12/drivers/: fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_port.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h
  group drivers_api
    ./drivers_api/: flash_api.c K64_api.h
  group md5
    ./md5/: md5.c md5Std.h
  group crc16
    ./crc16/: crc16.c lib_crc16.h
